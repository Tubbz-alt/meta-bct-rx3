FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI_append_bct-re3 = " file://0001-Add-shutdown-to-applications.patch"
SRC_URI_append_bct-rm3 = " file://0001-Add-shutdown-to-applications.patch"

