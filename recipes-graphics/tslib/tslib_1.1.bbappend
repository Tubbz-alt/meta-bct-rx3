# Layer priority will force do_patch() to pick up tslib.sh from this layer

FILESEXTRAPATHS_prepend := "${THISDIR}/tslib:"


