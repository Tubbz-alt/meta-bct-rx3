FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI_append_bct-rx3 = "file://0001-Remove-call-to-xf86XInputSetScreen.patch"


