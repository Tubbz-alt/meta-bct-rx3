FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append_bct-rx3 = " file://0001-Use-ts_calibrate-in-shortcut.patch"


